<?xml version='1.0' encoding='utf-8'?>
<?grc format='1' created='3.7.12'?>
<flow_graph>
<block>
<key>options</key>
<param><key>id</key><value>top_block</value></param>
<param><key>generate_options</key><value>qt_gui</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>rf_freq</value></param>
<param><key>value</key><value>2.4e9</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>samp_rate</value></param>
<param><key>value</key><value>40000000</value></param>
</block>
<block>
<key>qtgui_sink_x</key>
<param><key>id</key><value>qtgui_sink_x_0</value></param>
<param><key>bw</key><value>samp_rate</value></param>
<param><key>fc</key><value>0</value></param>
<param><key>freqchangevar</key><value>None</value></param>
<param><key>fftsize</key><value>1024</value></param>
<param><key>showports</key><value>True</value></param>
<param><key>type</key><value>complex</value></param>
<param><key>wintype</key><value>firdes.WIN_BLACKMAN_hARRIS</value></param>
</block>
<block>
<key>qtgui_sink_x</key>
<param><key>id</key><value>qtgui_sink_x_0_0</value></param>
<param><key>bw</key><value>samp_rate</value></param>
<param><key>fc</key><value>0</value></param>
<param><key>freqchangevar</key><value>None</value></param>
<param><key>fftsize</key><value>1024</value></param>
<param><key>showports</key><value>True</value></param>
<param><key>type</key><value>complex</value></param>
<param><key>wintype</key><value>firdes.WIN_BLACKMAN_hARRIS</value></param>
</block>
<block>
<key>yunsdr_source</key>
<param><key>id</key><value>yunsdr_source_0</value></param>
<param><key>buffer_size</key><value>0x8000</value></param>
<param><key>auto_filter</key><value>True</value></param>
<param><key>filter</key><value></value></param>
<param><key>gain1</key><value>"manual"</value></param>
<param><key>gain2</key><value>"manual"</value></param>
<param><key>frequency</key><value>1500000000</value></param>
<param><key>manual_gain1</key><value>50</value></param>
<param><key>manual_gain2</key><value>50</value></param>
<param><key>rf_port_select</key><value>"RX"</value></param>
<param><key>bandwidth</key><value>20000000</value></param>
<param><key>rx1_en</key><value>True</value></param>
<param><key>rx2_en</key><value>True</value></param>
<param><key>ref_clock</key><value>"internal"</value></param>
<param><key>samplerate</key><value>samp_rate</value></param>
<param><key>uri</key><value>192.168.0.135</value></param>
<param><key>vco</key><value>"auxdac1"</value></param>
</block>
<connection><source_block_id>yunsdr_source_0</source_block_id><sink_block_id>qtgui_sink_x_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>yunsdr_source_0</source_block_id><sink_block_id>qtgui_sink_x_0_0</sink_block_id><source_key>1</source_key><sink_key>0</sink_key></connection>
</flow_graph>
